# Keil uVision project PhotodiodePulse.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ATSAMD11D14AM Atmel
  pack: Keil.SAMD11_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PhotodiodePulse
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
